# IAR project IAR.ewp, settings and files
configuration IAR (ARM, debug)
  General.OGChipSelectEditMenu: APM32F103CB Geehy APM32F103CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; HSI_VALUE=8000000; LSI_VALUE=40000; VDD_VALUE=3300; PREFETCH_ENABLE=1; STM32F103xB; APM32F10X_LD; USE_FULL_ASSERT=1U; HSE_VALUE=16000000
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ../Core/Inc/; ../Core/Inc/CAN
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  AARM.AExtraOptionsV2: -g
  OBJCOPY.OOCOutputFile: IAR.hex
  ILINK.IlinkOutputFile: IAR.out
  ILINK.IlinkIcfFile: config\cm5.1-18-8_apm.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; HSE_VALUE=8000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; HSI_VALUE=8000000; LSI_VALUE=40000; VDD_VALUE=3300; PREFETCH_ENABLE=1; STM32F103xB
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 2
  ICCARM.IccLang: 0
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  group DPM_20_8_RBUS/User/Core
    ../Core/Src/: gpio.c main.c param.c spi.c stm32f1xx_it.c tim.c usart.c version.c
  group DPM_20_8_RBUS/User/Core/CAN
    ../Core/Src/CAN/: apm32f10x_bakr.c apm32f10x_can.c apm32f10x_pmu.c auxio2_mes.c bsp_can_apm.c CAN_process_tsk.c canengine.c datames_process.c fstore_params.c GlobalVar.c idlist.c j1939_address_claim.c memory_access_device.c misc.c platform.c rec_mes.c transport_protocol.c txdata.c txdata_base.c txrx.c warning.c
  group DPM_20_8_RBUS/User/Func
    ../Core/Src/Function/: Count.c FRAM.c RBUS.20.8.c ReadSC.c
  group DPM_R/EWARM
    ./: startup_stm32f103xb.s
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: apm32f10x_gpio.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_gpio.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_utils.c
    ../Core/Src/CAN/: apm32f10x_rcm.c
